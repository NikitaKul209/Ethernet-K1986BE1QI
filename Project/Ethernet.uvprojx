# Keil uVision project Ethernet.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: MDR1986BE1T Milandr
  pack: Keil.MDR1986BExx.2.0.3
  cpu: IRAM(0x20000000,0x8000) IRAM2(0x20100000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M1") CLOCK(12000000) ELITTLE
  output: Ethernet +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x4000
  group Source Group 1
    ./: main.c port.c port.h main.h clk.c clk.h ethernet.c ethernet.h tmr.c tmr.h adc.c adc.h
software components: Device:Startup 2.0.3, Drivers:ADC 2.0.3, Drivers:DMA 2.0.3, Drivers:EEPROM 2.0.3, Drivers:Ethernet 2.0.3, Drivers:PORT 2.0.3, Drivers:RST_CLK 2.0.3, Drivers:TIMER 2.0.3, Drivers:UART 2.0.3
